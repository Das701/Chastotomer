# Keil uVision project Panel.uvprojx, settings and files
target Panel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelDDS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c misc: --cpp --diag_suppress=1165
  c include: .\src;.\src\libs\HAL;.\src\Hardware;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\libs;..\common;.\src\libs\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_dma.h stm32f4xx_hal_tim_ex.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group libs/CMSIS
    ./src/libs/CMSIS/: system_stm32f4xx.c startup_stm32f437xx.s
  group libs/HAL
    ./src/libs/HAL/: stm32f4xx_hal_conf.h
  group libs/USBD
    ./src/libs/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_core.cpp usbd_desc.cpp usbd_desc.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
  group src
    ./src/: main.cpp defines.h Settings.cpp Settings.h
  group Display
    ./src/Display/: Display.cpp Display.h Primitives.cpp Primitives.h Colors.cpp Colors.h Display_HAL.cpp Text.cpp Text.h Symbols.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font7.inc font8.inc BigFont1.h fonttry2.cpp FontMid.cpp FontMid.h
  group FreqMeter
    ./src/FreqMeter/: FreqMeter.cpp FreqMeter.h
  group Hardware
    ./src/Hardware/: HAL.cpp HAL.h HAL_FSMC.cpp PLIS.cpp VCP.cpp VCP.h stm32f4xx_it.cpp
  group Keyboard
    ./src/Keyboard/: Keyboard.cpp Keyboard.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDef.h Hint.cpp Hint.h
  group Menu/Pages
    ./src/Menu/Pages/: PageChannelA.cpp PageChannelA.h PageChannelB.cpp PageChannelB.h PageChannelC.cpp PageChannelC.h PageChannelD.cpp PageChannelD.h PageIndication.cpp PageIndication.h PageModes.cpp PageModes.h PageModesB.cpp PageModesB.h PageModesC.cpp PageModesC.h PageModesD.cpp PageModesD.h
  group SCPI
    ./src/SCPI/: HeadSCPI.cpp SCPI.h SCPI.cpp
  group Utils
    ./src/Utils/: Buffer.h Buffer.cpp Math.h Math.cpp Stack.h Stack.cpp String.h String.cpp StringUtils.h StringUtils.cpp Values.h Values.cpp
